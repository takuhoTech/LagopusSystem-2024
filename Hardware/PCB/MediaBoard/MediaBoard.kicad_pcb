# Repository takuhoTech/LagopusSystem-2024

File README.md:

# LagopusSystem-2024
Avionics for Human-Powered Aircraft (Japan International Birdman Rally 2024)

## KiCad design Hardware/PCB/MediaBoard/MediaBoard.kicad_pcb

Parts:
C1: 4.7μ; C_0603_1608Metric
C2, C13: 10μF35V X5R 2012; C_0805_2012Metric
C3, C5: 220μF6.3V X5R 3225; C_1210_3225Metric
C4, C12: 0.1μ; C_0603_1608Metric
C6, C7, C8, C9, C10, C11: 1u; C_0603_1608Metric
D1, D2, D3, D4, D5, D6: SK6812MINI; LED_SK6812MINI_PLCC4_3.5x3.5mm_P1.75mm
J1, J2, J4, J5: Conn_01x07; PinSocket_1x07_P2.54mm_Vertical
J3: Micro_SD_Card_Det_Hirose_DM3AT; microSD_HC_Hirose_DM3AT-SF-PEJM5
J6: RGBLED; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
JP1: Gain; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: Stereo; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
JP3: Mono; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
LS1: Speaker; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
R1: 33; R_0603_1608Metric
R2, R3, R4, R5, R6: 10k; R_0603_1608Metric
R7, R8, R9: 22; R_0603_1608Metric
R10, R11: 510; R_0603_1608Metric
R12: 100k; R_0603_1608Metric
R13: 300k; R_0603_1608Metric
R14: 1M; R_0603_1608Metric
U1: WisdPi_Tiny_RP2040
U2: MAX98357; TQFN-16-1EP_3x3mm_P0.5mm_EP1.23x1.23mm_ThermalVias

Connections:
+3.3V: C1.1, C2.1, C4.1, J1.3, J3.4 (VDD), R2.2, R3.2, R4.2, R5.2, R6.2, U1.27 (3V3)
+5V: C3.2, C5.2, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, D1.4 (VDD), D2.4 (VDD), D3.4 (VDD), D4.4 (VDD), D5.4 (VDD), D6.4 (VDD), J1.1, J6.1, JP2.1 (A), R13.2, R14.2, U2.7 (VDD), U2.8 (VDD)
/BCLK: R8.2, U2.16 (BCLK)
/CS0: J3.2 (DAT3/CD), R5.1, U1.18 (GP17)
/DIN: R7.2, U2.1 (DIN)
/GAIN: JP1.2 (C), U2.2 (GAIN_SLOT)
/I2S_EN: J1.7
/LED_IN: J1.6, R10.1
/LED_OUT: J6.3, R11.2
/LRCLK: R9.2, U2.14 (LRCLK)
/MISO0: J3.7 (DAT0), R3.1, U1.17 (GP16)
/MOSI0: J3.3 (CMD), R4.1, U1.20 (GP19)
/SCK0: R1.1, U1.19 (GP18)
/~SD: JP2.2 (C), JP3.2 (B), U2.4 (~SD_MODE)
GND: C1.2, C2.2, C3.1, C4.2, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, D1.2 (VSS), D2.2 (VSS), D3.2 (VSS), D4.2 (VSS), D5.2 (VSS), D6.2 (VSS), J1.2, J3.6 (VSS), J3.11 (SHIELD), J6.2, JP1.3 (B), R12.1, U1.28 (GND), U2.3 (GND), U2.11 (GND), U2.15 (GND), U2.17 (EP)
MAIN_RX: J1.5, U1.1 (GP0)
MAIN_TX: J1.4, U1.2 (GP1)
unnamed: D1.1 (DOUT), D2.3 (DIN)
unnamed: D1.3 (DIN), R10.2
unnamed: D2.1 (DOUT), D3.3 (DIN)
unnamed: D3.1 (DOUT), D4.3 (DIN)
unnamed: D4.1 (DOUT), D5.3 (DIN)
unnamed: D5.1 (DOUT), D6.3 (DIN)
unnamed: D6.1 (DOUT), R11.1
unnamed: J3.1 (DAT2), R6.1
unnamed: J3.5 (CLK), R1.2
unnamed: J3.8 (DAT1), R2.1
unnamed: JP1.1 (A), R12.2
unnamed: JP2.3 (B), R13.1
unnamed: JP3.1 (A), R14.1
unnamed: LS1.1, U2.10 (OUTN)
unnamed: LS1.2, U2.9 (OUTP)
unnamed: R7.1, U1.10 (GP9)
unnamed: R8.1, U1.11 (GP10)
unnamed: R9.1, U1.12 (GP11)

Notes on the sheet:
CPU
NeoPixel RGB LED
Left Only
+9dB
Gain Select
+15dB
Interface
66uF @5V
+12dB
Right Only
I2S Audio
Output Channel Select

Board: 4 copper layers, 45 parts (0 on the bottom side), 34 nets, no tracks yet.

## KiCad design Hardware/PCB/CommunicationBoard/CommunicationBoard.kicad_pcb

Parts:
C1, C2, C3, C5, C6, C8: 0.1u; C_0603_1608Metric
C4, C7: 1u; C_0603_1608Metric
C9, C10: 10μF35V X5R 2012; C_0805_2012Metric
D1: CUHS20S30
D2: USB; LED_0603_1608Metric
D3: TWE_CLEAR; LED_0603_1608Metric
J1: SWD; PinHeader_2x05_P1.27mm_Vertical_SMD
J2, J3, J4: Conn_01x07; PinSocket_1x07_P2.54mm_Vertical
J6: USB_C_Receptacle_USB2.0; USB_C_Receptacle_5077CR-16-SMC2-BK-TR
J7: TWELITER; PinHeader_2x05_P1.27mm_Vertical_SMD
JP1: EX1; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2: BPS; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP3: SET; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R1, R2, R5, R6, R7, R11, R13, R14, R15: 10k; R_0603_1608Metric
R3, R4: 33; R_0603_1608Metric
R8, R9: 5.1k; R_0603_1608Metric
R10, R12: 1k; R_0603_1608Metric
R16: DNF; R_0603_1608Metric
SW1: nRF_RESET; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816
SW2: nRF_DFU; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816
SW3: TWE_CLEAR; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816
SW4: TWE_RESET; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816
SW5: TWE_PRG; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816
TP1: FRST; TestPoint_Pad_D1.0mm
U1: CH340K; SSOP-10_3.9x4.9mm_P1.00mm
U2: TMUX131; Texas_RMG0012A_1.8x1.8mm_P0.4mm
U3: ISP4520-AS; ISP4520-AS_with_Keep-Out
U4: USBLC6-2P6; SOT-666
U5: MW-R-WX; MonoWireless_TWE-L-WX
U7: 74AHC1G08; SOT-23-5

Connections:
+3.3V: C1.2, C2.1, C3.1, C4.1, C5.1, C7.2, C8.2, C9.1, C10.1, D1.1 (K), J1.1 (VTref), J2.3, J7.1 (VTref), R5.1, R6.1, R7.1, R11.1, R13.1, R14.1, R15.1, U1.7 (VCC), U1.10 (V3), U2.12 (VDD), U3.15 (VDD), U5.5 (VCC), U5.22 (ADC2/AI3), U5.23 (ADC1/AI1), U7.5 (VCC)
/BPS: JP2.2 (B), U5.19 (DIO17/BPS)
/CH340K_RXD: U1.9 (RXD), U2.3 (S1B)
/CH340K_TXD: R4.2, U2.4 (S2B)
/D+: J6.A6 (D+), J6.B6 (D+), U1.1 (UD+), U4.1 (I/O1)
/D-: J6.A7 (D-), J6.B7 (D-), U1.2 (UD-), U4.3 (I/O2)
/DFU: R11.2, SW2.1, U3.39 (P0_20/TRCCLK)
/DIO12: JP3.2 (B), U5.13 (DIO12/DI1)
/DTR: C6.1, U1.4 (~DTR)
/EX1: JP1.2 (B), R14.2, U5.24 (DIO0/AI2)
/FRST: TP1.1, U3.6 (P0_22)
/SCL: U3.5 (P0_07)
/SDA: U3.2 (P0_12)
/SEL0: R1.1, U2.1 (SEL0), U3.19 (P0_29_AIN5)
/SEL1: R2.1, U2.2 (SEL1), U3.20 (P0_28_AIN4)
/SWDCLK: J1.4 (SWDCLK/TCK), U3.37 (SWDCLK)
/SWDIO: J1.2 (SWDIO/TMS), U3.38 (SWDIO)
/SWO: J1.6 (SWO/TDO), U3.41 (P0_18/TRCDAT0)
/TWE_CLR: R13.2, SW3.1, U5.18 (DIO16/DI4), U5.26 (DIO2/M2), U5.27 (DIO3/M3), U7.1
/TWE_PRG: J7.2 (SWDIO/TMS), SW5.1, U5.2 (DO1/PWM3)
/TWE_RST: J7.10 (~RESET), SW4.1, U5.21 (~RESET)
/TWE_SET: J7.4 (SWDCLK/TCK), JP3.1 (A)
/TWE_UART_RTS: U3.13 (P0_03_AIN1), U5.7 (DIO5/PWM1)
/nRF52_RXD: U2.10 (D2), U3.8 (P0_08)
/nRF52_TXD: R3.1, U2.11 (D1)
/nRF_RST: C6.2, D1.2 (A), J1.10 (~RESET), R5.2, SW1.1, U3.40 (P0_21/RESET)
GND: C1.1, C2.2, C3.2, C4.2, C5.2, C7.1, C8.1, C9.2, C10.2, D2.1 (K), D3.1 (K), J1.3 (GND), J1.5 (GND), J1.9 (GNDDetect), J2.2, J6.A1 (GND), J6.A12 (GND), J6.B1 (GND), J6.B12 (GND), J6.S1 (SHIELD), J7.3 (GND), J7.5 (GND), J7.9 (GNDDetect), JP1.1 (A), JP2.1 (A), R1.2, R2.2, R8.2, R9.2, R16.2, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, U1.3 (GND), U1.11 (EP), U2.9 (GND), U3.1 (GND), U3.14 (GND), U3.21 (GND), U3.22 (GND), U3.23 (GND), U3.26 (GND), U3.27 (GND), U3.28 (GND), U3.29 (GND), U3.30 (GND), U3.31 (GND), U3.32 (GND), U3.33 (GND), U3.36 (GND), U3.74 (GND), U4.2 (GND), U5.20 (GND), U5.28 (GND), U5.30 (GND), U5.31 (GND), U5.32 (GND), U7.3 (GND)
unnamed: D2.2 (A), R10.2
unnamed: D3.2 (A), R12.2
unnamed: J6.A5 (CC1), R8.1
unnamed: J6.B5 (CC2), R9.1
unnamed: R3.2, U3.10 (P0_06)
unnamed: R4.1, U1.8 (TXD)
unnamed: R12.1, U5.3 (DIO18/DO1)
unnamed: R15.2, U5.25 (DIO1/AI4)
unnamed: R16.1, U5.17 (DIO15/SDA), U7.4
unnamed: U3.24 (LORA_TR), U3.25 (LORA_ANT)
unnamed: U3.34 (BLE_ANT), U3.35 (BLE_TR)
PICO_RX: J2.5, R7.2, U2.7 (S1A)
PICO_TX: J2.4, U2.6 (S2C)
TWE_RX: J7.8 (NC/TDI), U5.9 (DIO7/RX)
TWE_RX_SUB: R6.2, U2.5 (S1C), U7.2
TWE_TX: J7.6 (SWO/TDO), U5.8 (DIO6/TX)
TWE_TX_SUB: U2.8 (S2A), U5.14 (DIO14/SCL)
VBUS: J6.A4 (VBUS), J6.A9 (VBUS), J6.B4 (VBUS), J6.B9 (VBUS), R10.1, U4.5 (VBUS)

Notes on the sheet:
USB
Receive Mode
SPICLK:始動時に外部からGNDまたは中間的な電圧を 印加するとプログラムモードに遷移しない可能性
USB Mode
SETとPRGの位置は逆でもよい
SEL1 ---- Low Low High High
UART Mode
USB2Serial
BOOT
S1A
Transmit Mode
M1をGNDへ接続すると親機、開放またはVCCへ接続すると子機 フラッシュクリア時、M1 は Hiまたはオープン ->インタラクティブモードで解決
Debug
Interface
TWELITE R3
IO 4mA max
AとCを逆にする場合は SELに繋がるBaseModeとRoverModeを逆にする BaseModeがHighのときに送信するのは変わらないので REとDEはそのまま
| ------ | B | C | A | Disable
LoRa+BLE
UARTは正論理だが信号が無いときは3.3Vなのでプルアップ
Adafruit Featherで指定されているI2CピンはSX1261とのSPIで使われているため variant.hを編集して、ISP4520のデータシートの設計例で指定されている SCL:P0_07 SDA:P0_12 に変更
| SEL0 ----- | Low | High | Low | High
S2A
差動USBのダンピング抵抗はデータシートには無かった DTRはプッシュプル出力だが、4.7kでプルダウンすると USBコンフィギュレーションを外部から設定することができる
D:nRF側送信端だけダンピング B:CH340K側送信端だけダンピング C:PICO側ダンピングなし A:TWE側ダンピングなし TMUX131側送信端のダンピングは全て省略
TWE_RXはMUX側でプルアップ済
Low freq属性でないピンをsoftwareserialにしてデバッグに使う
SEL0とSEL1の内部プルダウンは6MΩ
UARTは1chまで 割り当てはAdafruit Featherに従った
| ----------- | USB Mode | Transmit Mode | Receive Mode | Disable
TWELITE

Board: 4 copper layers, 60.0 x 60.0 mm, 50 parts (0 on the bottom side), 43 nets.

File Hardware/PCB/CommunicationBoard/BOM.csv:

Source:,D:\GitHub\LagopusSystem-2024\Hardware\PCB\CommunicationBoard\CommunicationBoard.kicad_sch,,,,,
Date:,"2024/05/06 20:49:09",,,,,
Tool:,"Eeschema (6.0.9)",,,,,
Generator:,D:\KiCad\6.0\bin\scripting\plugins/bom_csv_grouped_by_value_with_fp.py,,,,,
"Component Count:",50,,,,,
Ref,Qnty,Value,"Cmp name",Footprint,Description,Vendor,,,,,
"C1, C2, C3, C5, C6, C8, ",6,0.1u,C_Small,Capacitor_SMD:C_0603_1608Metric,"Unpolarized capacitor, small symbol",,,,,,
"C4, C7, ",2,1u,C_Small,Capacitor_SMD:C_0603_1608Metric,"Unpolarized capacitor, small symbol",,,,,,
"C9, C10, ",2,"10μF35V X5R 2012",C_Small,Capacitor_SMD:C_0805_2012Metric,"Unpolarized capacitor, small symbol",,,,,,
"D1, ",1,CUHS20S30,D_Schottky_Small,CUHS20S30:CUHS20S30,"Schottky diode, small symbol",,,,,,
"D2, ",1,USB,LED_Small,LED_SMD:LED_0603_1608Metric,"Light emitting diode, small symbol",,,,,,
"D3, ",1,TWE_CLEAR,LED_Small,LED_SMD:LED_0603_1608Metric,"Light emitting diode, small symbol",,,,,,
"J1, ",1,SWD,Conn_ARM_JTAG_SWD_10,Connector_PinHeader_1.27mm:PinHeader_2x05_P1.27mm_Vertical_SMD,"Cortex Debug Connector, standard ARM Cortex-M SWD and JTAG interface",,,,,,
"J2, J3, J4, ",3,Conn_01x07,Conn_01x07,Connector_PinSocket_2.54mm:PinSocket_1x07_P2.54mm_Vertical,"Generic connector, single row, 01x07, script generated (kicad-library-utils/schlib/autogen/connector/)",,,,,,
"J6, ",1,USB_C_Receptacle_USB2.0,USB_C_Receptacle_USB2.0_1,Connector_USB_extlib:USB_C_Receptacle_5077CR-16-SMC2-BK-TR,"USB 2.0-only Type-C Receptacle connector",,,,,,
"J7, ",1,TWELITER,Conn_ARM_JTAG_SWD_10,Connector_PinHeader_1.27mm:PinHeader_2x05_P1.27mm_Vertical_SMD,"Cortex Debug Connector, standard ARM Cortex-M SWD and JTAG interface",,,,,,
"JP1, ",1,EX1,SolderJumper_2_Open,Jumper:SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm,"Solder Jumper, 2-pole, open",,,,,,
"JP2, ",1,BPS,SolderJumper_2_Open,Jumper:SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm,"Solder Jumper, 2-pole, open",,,,,,
"JP3, ",1,SET,SolderJumper_2_Open,Jumper:SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm,"Solder Jumper, 2-pole, open",,,,,,
"R1, R2, R5, R6, R7, R11, R13, R14, R15, ",9,10k,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,,
"R3, R4, ",2,33,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,,
"R8, R9, ",2,5.1k,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,,
"R10, R12, ",2,1k,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,,
"R16, ",1,DNF,R_Small,Resistor_SMD:R_0603_1608Metric,"Resistor, small symbol",,,,,,
"SW1, ",1,nRF_RESET,SW_Push,Button_Switch_SMD:SW_Push_1P1T_NO_Vertical_Wuerth_434133025816,"Push button switch, generic, two pins",,,,,,
"SW2, ",1,nRF_DFU,SW_Push,Button_Switch_SMD:SW_Push_1P1T_NO_Vertical_Wuerth_434133025816,"Push button switch, generic, two pins",,,,,,
"SW3, ",1,TWE_CLEAR,SW_Push,Button_Switch_SMD:SW_Push_1P1T_NO_Vertical_Wuerth_434133025816,"Push button switch, generic, two pins",,,,,,
"SW4, ",1,TWE_RESET,SW_Push,Button_Switch_SMD:SW_Push_1P1T_NO_Vertical_Wuerth_434133025816,"Push button switch, generic, two pins",,,,,,
"SW5, ",1,TWE_PRG,SW_Push_45deg,Button_Switch_SMD:SW_Push_1P1T_NO_Vertical_Wuerth_434133025816,"Push button switch, normally open, two pins, 45° tilted",,,,,,
"TP1, ",1,FRST,TestPoint,TestPoint:TestPoint_Pad_D1.0mm,"test point",,,,,,
"U1, ",1,CH340K,CH340K,Package_SO:SSOP-10_3.9x4.9mm_P1.00mm,"USB serial converter, UART, ESSOP-10",,,,,,
"U2, ",1,TMUX131,TMUX131,Package_DFN_QFN_extlib:Texas_RMG0012A_1.8x1.8mm_P0.4mm,,,,,,,
"U3, ",1,ISP4520-AS,ISP4520-AS,RF_Module_extlib:ISP4520-AS_with_Keep-Out,,,,,,,
"U4, ",1,USBLC6-2P6,USBLC6-2P6,Package_TO_SOT_SMD:SOT-666,"Very low capacitance ESD protection diode, 2 data-line, SOT-666",,,,,,
"U5, ",1,MW-R-WX,MW-R-WX,RF_Module:MonoWireless_TWE-L-WX,"NXP JN5164/JN5169 breakout module, SMD",,,,,,
"U7, ",1,74AHC1G08,74AHC1G08,Package_TO_SOT_SMD:SOT-23-5,"Single AND Gate, Low-Voltage CMOS",,,,,,

## KiCad design Hardware/PCB/TWELiteWriter/TWELiteWriter.kicad_pcb

Parts:
J1: TWELITER; PinHeader_2x05_P1.27mm_Vertical_SMD
JP1: VCC; PinHeader_1x02_P2.54mm_Vertical
JP2: SET; PinHeader_1x02_P2.54mm_Vertical
U1: TWELITE_R3; PinSocket_1x07_P2.54mm_Horizontal

Connections:
+3.3V: J1.1 (VTref), JP1.1 (A)
/TWE_PRG: J1.2 (SWDIO/TMS), U1.3 (PRG)
/TWE_RST: J1.10 (~RESET), U1.5 (RST)
/TWE_RX: J1.8 (NC/TDI), U1.4 (RXD)
/TWE_SET: J1.4 (SWDCLK/TCK), JP2.1 (A)
/TWE_TX: J1.6 (SWO/TDO), U1.2 (TXD)
GND: J1.3 (GND), J1.5 (GND), J1.9 (GNDDetect), U1.1 (GND)
unnamed: JP2.2 (B), U1.7 (SET)
VCC: JP1.2 (B), U1.6 (VCC)

Board: 2 copper layers, 30.0 x 20.0 mm, 4 parts (1 on the bottom side), 9 nets.

## KiCad design Hardware/PCB/SWDWriter/SWDWriter.kicad_pcb

Parts:
J1: SWD; PinHeader_2x05_P1.27mm_Vertical_SMD
J2: AE-LPC11U35-MB; DIP-30_W15.24mm
JP1: VCC; PinHeader_1x02_P2.54mm_Vertical
SW1: SW_Push; SW_PUSH_6mm_H4.3mm

Connections:
+3.3V: J1.1 (VTref), JP1.1 (A)
+5V: J2.2
/SWDCLK: J1.4 (SWDCLK/TCK), J2.3
/SWDIO: J1.2 (SWDIO/TMS), J2.4
/SWO: J1.6 (SWO/TDO)
/TDI: J1.8 (NC/TDI)
/nRF_RST: J1.10 (~RESET), SW1.1
GND: J1.3 (GND), J1.5 (GND), J1.9 (GNDDetect), J2.1, J2.30, SW1.2
VCC: J2.29, JP1.2 (B)

Board: 2 copper layers, 20.0 x 50.0 mm, 4 parts (0 on the bottom side), 6 nets.

## KiCad design Hardware/PCB/BatteryBoard/BatteryBoard.kicad_pcb

Parts:
BT1, BT2: BATT; BatteryClip_Keystone_18500_Protected
C1, C7, C10: 10μF100V X7S 3225; C_1210_3225Metric
C2, C3, C8, C11, C20, C21: 0.1u; C_0603_1608Metric
C4, C18, C19: 1u; C_0603_1608Metric
C5: 4.7u; C_0603_1608Metric
C6: 0.047u; C_0603_1608Metric
C9: 47p; C_0603_1608Metric
C16, C17: 47μF16V X6S 3225; C_1210_3225Metric
C22, C24: 100μF10V X5R 3216; C_1206_3216Metric
C23: 10μF35V X5R 2012; C_0805_2012Metric
C25: 220μF4V X6S 3216; C_1206_3216Metric
C30, C31: 4.7μF50V X7S 2012; C_0805_2012Metric
D1: STAT; LED_0603_1608Metric
D2: PWRGOOD; LED_0603_1608Metric
D3: ESDA13P70-1U1M
F1: Polyfuse_Small; ASMDC300F_24-2
H1, H2, H3, H4: MH; MountingHole_2.2mm_M2_Pad_Via
J1: USB_C_Receptacle_USB2.0; CUI_UJC-HP-3-SMT-TR
J2: Thermistor; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J3, J4, J5, J6: Conn_01x07; PinSocket_1x07_P2.54mm_Vertical
J7: Power; PinHeader_1x04_P2.54mm_Vertical
L1, L2, L3: 1uH; L_1210_3225Metric
Q1, Q2: FDS4935A; SOIC-8_3.9x4.9mm_P1.27mm
R1, R6: 330k 0.1%; R_0603_1608Metric
R2: 27k 0.1%; R_0603_1608Metric
R3: 75k 0.1%; R_0603_1608Metric
R4: 68k 0.1%; R_0603_1608Metric
R5, R8: 47k 0.1%; R_0603_1608Metric
R7, R14: 30k 0.1%; R_0603_1608Metric
R9, R10: 5.1k; R_0603_1608Metric
R11: 510k 5%; R_0603_1608Metric
R12: 0; R_0603_1608Metric
R13: 5.1k 0.1%; R_0603_1608Metric
R15, R16, R17: 4.7k; R_0603_1608Metric
R18, R19: 1k; R_0603_1608Metric
R20: 390k 5%; R_0603_1608Metric
R21: 560 0.1%; R_0603_1608Metric
R22: 330; R_0603_1608Metric
R23: 10(3216); R_1206_3216Metric
R24, R25: 10k; R_0603_1608Metric
R26: 680k 5%; R_0603_1608Metric
R27: 130k 0.1%; R_0603_1608Metric
R28: 470k 5%; R_0603_1608Metric
R29: 150k 0.1%; R_0603_1608Metric
SW1: SW_SPDT; NKK_SS-12SDP2
U1: BQ25887RGER; VQFN-24-1EP_4x4mm_P0.5mm_EP2.45x2.45mm_ThermalVias; Manufacturer_Part_Number BQ25887RGER; Mouser Part Number 595-BQ25887RGER
U2: LTC4417CGN; SSOP-24_3.9x8.7mm_P0.635mm
U3, U4: TPS63070; VQFN-15-HR(3X2.5)

Connections:
+3.3V: C23.1, C25.1, J3.3, J4.3, J5.3, J6.3, J7.4, R15.2, R16.2, R17.2, R28.2, U4.P$7/8 (VOUT)
+5V: C22.1, C24.1, J3.1, J4.1, J5.1, J6.1, J7.1, R26.2, U3.P$7/8 (VOUT)
+5VREF: C5.1, R13.2, R18.2, R19.2, U1.11 (REGN)
+BATT: BT1.1 (+), C7.1, F1.1, U1.13 (BAT), U1.14 (BAT)
/G1: Q1.2 (G), Q1.4 (G), U2.20 (G1)
/G2: Q2.2 (G), Q2.4 (G), U2.18 (G2)
/OV1: R5.1, U2.5 (OV1)
/OV2: R12.1, U2.7 (OV2)
/UV1: R4.1, U2.4 (UV1)
/UV2: R11.1, U2.6 (UV2)
/VBAT_VALID: U2.11 (~VALID2)
/VBUS_VALID: U2.10 (~VALID1)
/VS1: C8.1, Q1.1 (S), Q1.3 (S), U2.21 (VS1)
/VS2: C11.1, Q2.1 (S), Q2.3 (S), U2.19 (VS2)
CBSET: R23.2, U1.10 (CBSET)
CD: U1.3 (CD)
GND: BT2.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C30.2, C31.2, D3.2 (A), H1.1, H2.1, H3.1, H4.1, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), J1.S1 (SHIELD), J2.1, J3.2, J4.2, J5.2, J6.2, J7.2, J7.3, R3.2, R8.2, R9.2, R10.2, R14.1, R20.2, R21.1, R27.1, R29.1, SW1.1 (A), U1.19 (GND), U1.20 (GND), U1.25 (EP), U2.8 (UV3), U2.9 (OV3), U2.13 (GND), U2.16 (G3), U2.17 (VS3), U2.22 (V3), U3.P$4 (GND), U3.P$6 (FB2), U3.P$10 (PGND), U3.P$15 (VSEL), U4.P$4 (GND), U4.P$6 (FB2), U4.P$10 (PGND), U4.P$15 (VSEL)
INT: J3.7, R17.1, U1.6 (~INT)
MID: R22.2, U1.9 (MID)
unnamed: BT1.2 (-), BT2.1 (+), R22.1, R23.1
unnamed: C6.1, U1.12 (BTST)
unnamed: C9.1, U1.15 (SNS), U1.16 (SNS)
unnamed: C20.1, U3.P$3 (VAUX)
unnamed: C21.1, U4.P$3 (VAUX)
unnamed: D1.1 (K), U1.2 (STAT)
unnamed: D1.2 (A), R18.1
unnamed: D2.1 (K), U1.1 (~PG)
unnamed: D2.2 (A), R19.1
unnamed: J1.A5 (CC1), R9.1
unnamed: J1.B5 (CC2), R10.1
unnamed: L2.1, U3.P$11 (L1)
unnamed: L2.2, U3.P$9 (L2)
unnamed: L3.1, U4.P$11 (L1)
unnamed: L3.2, U4.P$9 (L2)
unnamed: R1.2, R2.1, R4.2
unnamed: R2.2, R3.1, R5.2
unnamed: R6.2, R7.1, R11.2
unnamed: R7.2, R8.1, R12.2
unnamed: R20.1, U2.3 (HYS)
unnamed: R21.2, U1.8 (ILIM)
unnamed: R24.1, U3.P$1 (PS/SYNC), U3.P$14 (~EN)
unnamed: R25.1, U4.P$1 (PS/SYNC), U4.P$14 (~EN)
unnamed: R26.1, R27.2, U3.P$5 (FB)
unnamed: R28.1, R29.2, U4.P$5 (FB)
unnamed: SW1.2 (B), U2.2 (~SHDN)
PMID: C10.1, L1.2, U1.21 (PMID), U1.22 (PMID)
PSEL: J3.6, U1.24 (PSEL)
SCL: J3.5, R16.1, U1.5 (SCL)
SDA: J3.4, R15.1, U1.4 (SDA)
SW: C6.2, L1.1, U1.17 (SW), U1.18 (SW)
TS: J2.2, R13.1, R14.2, U1.7 (TS)
VBAT: C2.1, F1.2, Q2.5 (D), Q2.6 (G), R6.1, U2.23 (V2)
VBUS: C1.1, C3.1, C4.1, C30.1, C31.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), Q1.5 (D), Q1.6 (G), R1.1, U1.23 (VBUS), U2.24 (V1)
VDD: C16.1, C17.1, C18.1, C19.1, D3.1 (K), Q1.7 (D), Q1.8 (G), Q2.7 (D), Q2.8 (G), R24.2, R25.2, U2.15 (VOUT), U3.P$12/13 (VIN), U4.P$12/13 (VIN)

Notes on the sheet:
出力コンデンサは BBコンバータの入力コンデンサと共有
Thermistor
ActiveHigh ChipDisable
34uF @5V
88uF @3.3V
Interface
Type-C Current
OFF
+5VREF Max:50mA
Under/Over voltage fault
FETでBQ25887とバッテリの接続を切ると12uAを節約できるが ボディダイオードの順方向電圧のために充電できなくなる 理想ダイオードを追加しても怪しい
Buck-Boost Converter
PowerPath Control
5V to 8.4V
8uF @3.3V
Charge

Board: 4 copper layers, 60.0 x 60.0 mm, 79 parts (0 on the bottom side), 51 nets.
